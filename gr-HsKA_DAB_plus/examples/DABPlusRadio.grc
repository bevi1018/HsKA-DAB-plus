<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>carrier_count</value></param>
<param><key>value</key><value>1536</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_frequency</value></param>
<param><key>value</key><value>178352000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cyclic_prefix_length</value></param>
<param><key>value</key><value>504</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>2048</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>value</key><value>50</value></param>
<param><key>gui_hint</key><value>tab_widget@1</value></param>
<param><key>label</key><value>Freq. Corr [ppm]</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain_slider</value></param>
<param><key>value</key><value>45</value></param>
<param><key>gui_hint</key><value>tab_widget@1</value></param>
<param><key>label</key><value>RF Gain [dB]</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>snr_slider</value></param>
<param><key>value</key><value>15</value></param>
<param><key>gui_hint</key><value>tab_widget@1</value></param>
<param><key>label</key><value>SNR [dB]</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>HsKA_DAB_plus_CRC16</key>
<param><key>id</key><value>HsKA_DAB_plus_CRC16_0</value></param>
<param><key>debug_on</key><value>0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>polynom</key><value>0x1021</value></param>
</block>
<block>
<key>HsKA_DAB_plus_DQPSK_Demodulation</key>
<param><key>id</key><value>HsKA_DAB_plus_DQPSK_Demodulation_0</value></param>
<param><key>fft_length</key><value>fft_size</value></param>
<param><key>N</key><value>carrier_count</value></param>
</block>
<block>
<key>HsKA_DAB_plus_Departitioning</key>
<param><key>id</key><value>HsKA_DAB_plus_Departitioning_0</value></param>
<param><key>database_id</key><value>fic_database</value></param>
<param><key>DEBUG_ON</key><value>0</value></param>
<param><key>vector_length</key><value>carrier_count</value></param>
</block>
<block>
<key>HsKA_DAB_plus_FIC_Scrambler</key>
<param><key>id</key><value>HsKA_DAB_plus_FIC_Scrambler_0</value></param>
</block>
<block>
<key>HsKA_DAB_plus_Frequency_Deinterleaver</key>
<param><key>id</key><value>HsKA_DAB_plus_Frequency_Deinterleaver_0</value></param>
<param><key>fft_length</key><value>fft_size</value></param>
<param><key>N</key><value>carrier_count</value></param>
</block>
<block>
<key>HsKA_DAB_plus_MP4_decoder</key>
<param><key>id</key><value>HsKA_DAB_plus_MP4_decoder_0</value></param>
<param><key>debug_enable</key><value>0</value></param>
</block>
<block>
<key>HsKA_DAB_plus_MSC_Scrambler</key>
<param><key>id</key><value>HsKA_DAB_plus_MSC_Scrambler_0</value></param>
</block>
<block>
<key>HsKA_DAB_plus_OFDM_Symbol_Synchronisation</key>
<param><key>id</key><value>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_1</value></param>
<param><key>Averaging</key><value>8</value></param>
<param><key>L</key><value>504</value></param>
<param><key>DEBUG_ON</key><value>0</value></param>
<param><key>N</key><value>2048</value></param>
<param><key>SNR</key><value>15</value></param>
</block>
<block>
<key>HsKA_DAB_plus_OFDM_coarse_frequency_correction</key>
<param><key>id</key><value>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</value></param>
<param><key>cp_length</key><value>cyclic_prefix_length</value></param>
<param><key>DEBUG_ON</key><value>0</value></param>
<param><key>fft_length</key><value>fft_size</value></param>
<param><key>num_carriers</key><value>carrier_count</value></param>
</block>
<block>
<key>HsKA_DAB_plus_Remove_First_OFDM_Symbol</key>
<param><key>id</key><value>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</value></param>
<param><key>vector_length</key><value>carrier_count</value></param>
</block>
<block>
<key>HsKA_DAB_plus_Soft_Demapper</key>
<param><key>id</key><value>HsKA_DAB_plus_Soft_Demapper_0</value></param>
<param><key>vector_length</key><value>carrier_count</value></param>
</block>
<block>
<key>HsKA_DAB_plus_Super_Frame_Synchronisation</key>
<param><key>id</key><value>HsKA_DAB_plus_Super_Frame_Synchronisation_0</value></param>
<param><key>DEBUG_ON</key><value>0</value></param>
<param><key>LOOK_AHEAD</key><value>100</value></param>
<param><key>T_NULL</key><value>2656</value></param>
</block>
<block>
<key>HsKA_DAB_plus_fib_decoder</key>
<param><key>id</key><value>HsKA_DAB_plus_fib_decoder_0</value></param>
<param><key>databaseID</key><value>fic_database</value></param>
<param><key>DEBUG_ON</key><value>0</value></param>
</block>
<block>
<key>HsKA_DAB_plus_firecode_checker</key>
<param><key>id</key><value>HsKA_DAB_plus_firecode_checker_0</value></param>
<param><key>debug_on</key><value>0</value></param>
</block>
<block>
<key>HsKA_DAB_plus_radio_gui</key>
<param><key>id</key><value>HsKA_DAB_plus_radio_gui_0</value></param>
<param><key>database_id</key><value>fic_database</value></param>
<param><key>debug</key><value>0</value></param>
<param><key>center_frequency_var</key><value>center_frequency</value></param>
<param><key>gui_hint</key><value>tab_widget@0</value></param>
</block>
<block>
<key>HsKA_DAB_plus_reed_solomon_decoder</key>
<param><key>id</key><value>HsKA_DAB_plus_reed_solomon_decoder_0</value></param>
<param><key>debug_enable</key><value>0</value></param>
</block>
<block>
<key>HsKA_DAB_plus_time_deinterleaver</key>
<param><key>id</key><value>HsKA_DAB_plus_time_deinterleaver_0</value></param>
<param><key>vector_length</key><value>3456</value></param>
</block>
<block>
<key>HsKA_DAB_plus_unpuncture_fic</key>
<param><key>id</key><value>HsKA_DAB_plus_unpuncture_fic_0</value></param>
<param><key>vector_length</key><value>1536</value></param>
</block>
<block>
<key>HsKA_DAB_plus_unpuncture_msc</key>
<param><key>id</key><value>HsKA_DAB_plus_unpuncture_msc_0</value></param>
<param><key>databaseID</key><value>fic_database</value></param>
<param><key>debug</key><value>0</value></param>
</block>
<block>
<key>HsKA_DAB_plus_viterbi_wrapper</key>
<param><key>id</key><value>HsKA_DAB_plus_viterbi_wrapper_0</value></param>
<param><key>table</key><value>[1,1,1,1,1,1,1,-1,1,1,-1,1,1,1,-1,-1,1,-1,1,1,1,-1,1,-1,1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,-1,1,1,-1,-1,1,-1,1,-1,1,-1,-1,-1,-1,1,1,-1,-1,1,-1,-1,-1,-1,1,-1,-1,-1,-1]</value></param>
<param><key>dimension</key><value>4</value></param>
<param><key>fsm_in</key><value>1</value></param>
<param><key>fsm_out</key><value>4</value></param>
<param><key>fsm_table</key><value>[0133, 0171, 0145, 0133]</value></param>
<param><key>final_state</key><value>0</value></param>
<param><key>init_state</key><value>0</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>carrier_count</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/gnuradiouser/gnuradio/HsKA-DAB-plus/Signal Examples/DAB+_Radio_Signal_218640000</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>4</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value></value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>tab_widget@1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>xmax</key><value>500</value></param>
<param><key>xmin</key><value>-500</value></param>
<param><key>ymax</key><value>500</value></param>
<param><key>ymin</key><value>-500</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>corr0</key><value>freq_corr</value></param>
<param><key>freq0</key><value>center_frequency</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>rf_gain_slider</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>tab_widget</value></param>
<param><key>label0</key><value>Radio GUI</value></param>
<param><key>label1</key><value>Constellation</value></param>
<param><key>num_tabs</key><value>2</value></param>
</block>
<block>
<key>trellis_viterbi_combined_xx</key>
<param><key>id</key><value>trellis_viterbi_combined_xx_0</value></param>
<param><key>block_size</key><value>774</value></param>
<param><key>table</key><value>[1,1,1,1,1,1,1,-1,1,1,-1,1,1,1,-1,-1,1,-1,1,1,1,-1,1,-1,1,-1,-1,1,1,-1,-1,-1,-1,1,1,1,-1,1,1,-1,-1,1,-1,1,-1,1,-1,-1,-1,-1,1,1,-1,-1,1,-1,-1,-1,-1,1,-1,-1,-1,-1]</value></param>
<param><key>dim</key><value>4</value></param>
<param><key>fsm_args</key><value>1,4,[0133, 0171, 0145, 0133]</value></param>
<param><key>final_state</key><value>0</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>type</key><value>f</value></param>
<param><key>metric_type</key><value>digital.TRELLIS_EUCLIDEAN</value></param>
<param><key>out_type</key><value>b</value></param>
</block>
<connection><source_block_id>HsKA_DAB_plus_CRC16_0</source_block_id><sink_block_id>HsKA_DAB_plus_fib_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</source_block_id><sink_block_id>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</source_block_id><sink_block_id>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Departitioning_0</source_block_id><sink_block_id>HsKA_DAB_plus_unpuncture_fic_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Departitioning_0</source_block_id><sink_block_id>HsKA_DAB_plus_time_deinterleaver_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Departitioning_0</source_block_id><sink_block_id>HsKA_DAB_plus_time_deinterleaver_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_FIC_Scrambler_0</source_block_id><sink_block_id>HsKA_DAB_plus_CRC16_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Frequency_Deinterleaver_0</source_block_id><sink_block_id>HsKA_DAB_plus_Soft_Demapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Frequency_Deinterleaver_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_MP4_decoder_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_MP4_decoder_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_MSC_Scrambler_0</source_block_id><sink_block_id>HsKA_DAB_plus_firecode_checker_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_MSC_Scrambler_0</source_block_id><sink_block_id>HsKA_DAB_plus_firecode_checker_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_1</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_1</source_block_id><sink_block_id>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_1</source_block_id><sink_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</source_block_id><sink_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</source_block_id><sink_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</source_block_id><sink_block_id>HsKA_DAB_plus_Frequency_Deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</source_block_id><sink_block_id>HsKA_DAB_plus_Departitioning_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Soft_Demapper_0</source_block_id><sink_block_id>HsKA_DAB_plus_Departitioning_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Super_Frame_Synchronisation_0</source_block_id><sink_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Super_Frame_Synchronisation_0</source_block_id><sink_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_firecode_checker_0</source_block_id><sink_block_id>HsKA_DAB_plus_reed_solomon_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_firecode_checker_0</source_block_id><sink_block_id>HsKA_DAB_plus_reed_solomon_decoder_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_reed_solomon_decoder_0</source_block_id><sink_block_id>HsKA_DAB_plus_MP4_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_reed_solomon_decoder_0</source_block_id><sink_block_id>HsKA_DAB_plus_MP4_decoder_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_time_deinterleaver_0</source_block_id><sink_block_id>HsKA_DAB_plus_unpuncture_msc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_time_deinterleaver_0</source_block_id><sink_block_id>HsKA_DAB_plus_unpuncture_msc_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_unpuncture_fic_0</source_block_id><sink_block_id>trellis_viterbi_combined_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_unpuncture_msc_0</source_block_id><sink_block_id>HsKA_DAB_plus_viterbi_wrapper_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_unpuncture_msc_0</source_block_id><sink_block_id>HsKA_DAB_plus_viterbi_wrapper_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_unpuncture_msc_0</source_block_id><sink_block_id>HsKA_DAB_plus_viterbi_wrapper_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_viterbi_wrapper_0</source_block_id><sink_block_id>HsKA_DAB_plus_MSC_Scrambler_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_viterbi_wrapper_0</source_block_id><sink_block_id>HsKA_DAB_plus_MSC_Scrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_viterbi_wrapper_0</source_block_id><sink_block_id>HsKA_DAB_plus_MSC_Scrambler_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>HsKA_DAB_plus_Super_Frame_Synchronisation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>HsKA_DAB_plus_Super_Frame_Synchronisation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_viterbi_combined_xx_0</source_block_id><sink_block_id>HsKA_DAB_plus_FIC_Scrambler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
