<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2048000</value></param>
</block>
<block>
<key>HsKA_DAB_plus_DQPSK_Demodulation</key>
<param><key>id</key><value>HsKA_DAB_plus_DQPSK_Demodulation_0</value></param>
<param><key>fft_length</key><value>2048</value></param>
<param><key>N</key><value>1536</value></param>
</block>
<block>
<key>HsKA_DAB_plus_Frequency_Deinterleaver</key>
<param><key>id</key><value>HsKA_DAB_plus_Frequency_Deinterleaver_0</value></param>
<param><key>fft_length</key><value>2048</value></param>
<param><key>N</key><value>1536</value></param>
</block>
<block>
<key>HsKA_DAB_plus_OFDM_Symbol_Synchronisation</key>
<param><key>id</key><value>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_0</value></param>
<param><key>Averaging</key><value>8</value></param>
<param><key>L</key><value>504</value></param>
<param><key>N</key><value>2048</value></param>
<param><key>SNR</key><value>15</value></param>
</block>
<block>
<key>HsKA_DAB_plus_OFDM_coarse_frequency_correction</key>
<param><key>id</key><value>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</value></param>
<param><key>cp_length</key><value>504</value></param>
<param><key>fft_length</key><value>2048</value></param>
<param><key>num_carriers</key><value>1536</value></param>
</block>
<block>
<key>HsKA_DAB_plus_Remove_First_OFDM_Symbol</key>
<param><key>id</key><value>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</value></param>
<param><key>vector_length</key><value>1536</value></param>
</block>
<block>
<key>HsKA_DAB_plus_Super_Frame_Synchronisation</key>
<param><key>id</key><value>HsKA_DAB_plus_Super_Frame_Synchronisation_0</value></param>
<param><key>LOOK_AHEAD</key><value>10</value></param>
<param><key>T_NULL</key><value>2656</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1536</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/gnuradiouser/gnuradio/HsKA-DAB+/Signal Examples/DAB+_Radio_Signal_218640000</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.rectangular(2048)</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>size</key><value>1536</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>218614000</value></param>
<param><key>gain_mode0</key><value>True</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>args</key><value></value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</source_block_id><sink_block_id>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</source_block_id><sink_block_id>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Frequency_Deinterleaver_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_0</source_block_id><sink_block_id>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_0</source_block_id><sink_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</source_block_id><sink_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</source_block_id><sink_block_id>HsKA_DAB_plus_DQPSK_Demodulation_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</source_block_id><sink_block_id>HsKA_DAB_plus_Frequency_Deinterleaver_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Remove_First_OFDM_Symbol_0</source_block_id><sink_block_id>blocks_null_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Super_Frame_Synchronisation_0</source_block_id><sink_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>HsKA_DAB_plus_Super_Frame_Synchronisation_0</source_block_id><sink_block_id>HsKA_DAB_plus_OFDM_Symbol_Synchronisation_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>HsKA_DAB_plus_Super_Frame_Synchronisation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>HsKA_DAB_plus_OFDM_coarse_frequency_correction_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>HsKA_DAB_plus_Super_Frame_Synchronisation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
